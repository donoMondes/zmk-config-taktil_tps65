## config/boards/shields/TakTil/Kconfig.shield
```kconfig
rsource "../../../drivers/sensor/Kconfig"

config SHIELD_TAKTIL
    def_bool $(shields_list_contains, TakTil)
```
